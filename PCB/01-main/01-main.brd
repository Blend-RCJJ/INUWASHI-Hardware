# Repository Blend-RCJJ/INUWASHI-Hardware

File README.md:

# INUWASHI-Hardware

2023 Bordeaux機 「INUWASHI」のハードウェアリポジトリ

## License 諸注意

CC-BY-NC-SA 4.0

- 商用利用不可
- 継承義務
- 改変可能

現役勢の皆様はルールの**ロボットはチームメンバー自身によって製作された物でなければならない。** に抵触しないようにご注意願います。（参考にしていただく分には歓迎です👌）

## 3D Data

私たちは機体の設計にAutodesk Fusion360を使用しています。機体の最新の設計データのリンクはこちらです。ダウンロードをご希望の方はTwitterのDMにて個別にお知らせください。

[https://a360.co/41CARyh](https://a360.co/41CARyh)

## フォルダ構成

- CFRP_DXF　カーボン発注のDXFファイル
- PCB　基板データ（Autodesk Eagle）
  - 01-main　メイン基板
  - 02-UI　UI基板
  - 03-ToF　距離センサ基板
  - 04-bottom　下段基板
  - 05-PWR　電源基板

## Topic

最近近くの伊吹山でいぬわしのひなが生まれたらしいです。ぴよぴよかわいいね！！

## EAGLE design PCB/01-main/01-main.brd

Parts:
C1: 4.7µ; C0603
C2, C3, C4, C5, C6, C7, C11, C14: 0.1µ; C0603
C8, C17: 1µ; C0603
C9, C10, C12, C13, C15: 100μ; 153CLV-0505
D1, D2: 1N4001; SMA-DO214AC
JP1: PINHD-1X2; 1X02
JP2: PINHD-1X5; 1X05
LED15: BLUE; SML0603
LED17, LED18: WHITE; SML0603
R1, R2: 5k1; R0402
R3, R10, R32: 270; R0402
R12, R13: 10k; R0402
REG1: REG-3V3; MYPARTS_D-PAK_TO252AA
REG2: REG-5V; MYPARTS_D-PAK_TO252AA
U1: CH340ESMD; MSOP10
U2: STM32F446RET6; LQFP64-10X10MM
U4: BNO055; SOCKET-08
X2: usb-c; USB_C_CUSB31-CFM2AX-01-X

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, D1.A, R12.1, R13.1, REG1.3 (VOUT), U2.1 (VBAT), U2.13 (VDDA/VREF+), U2.19 (VDD_2), U2.32 (VDD_3), U2.48 (VDD_4), U2.64 (VDD), U4.1 (VIN); also elsewhere on the board
+5V: C11.1, D2.A, REG2.3 (VOUT), U1.7 (VCC); also elsewhere on the board
BOOT0: U2.60 (BOOT0); also elsewhere on the board
CTS: U1.5 (CTS)
D+: U1.1 (UD+), X2.A6 (D+), X2.B6 (D+)
D-: U1.2 (UD-), X2.A7 (D-), X2.B7 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.-, C10.-, C11.2, C12.-, C13.-, C14.2, C15.-, C17.2, JP1.1, LED18.C, R1.2, R2.2, R3.1, R32.1, REG1.4 (GND), REG2.4 (GND), U1.3 (GND), U2.12 (VSSA/VREF-), U2.18 (VSS_2), U2.31 (VSS_3), U2.47 (VSS_4), U2.63 (VSS), U4.2 (GND), U4.7 (GND), X2.A1B12 (GND), X2.B1A12 (GND); also elsewhere on the board
LED-FLOOR: U2.36 (PB15); also elsewhere on the board
LED-L: U2.50 (PA15); also elsewhere on the board
LED-R: U2.34 (PB13); also elsewhere on the board
LED-TOP: U2.9 (PC1); also elsewhere on the board
LED-UI: U2.35 (PB14); also elsewhere on the board
LED-WHITE: LED17.A, U2.33 (PB12)
LOADCELL-L: U2.10 (PC2); also elsewhere on the board
LOADCELL-R: U2.11 (PC3); also elsewhere on the board
MIRROR: U2.44 (PA11); also elsewhere on the board
unnamed: C14.1, U1.10 (V3)
unnamed: R1.1, X2.A5 (CC1)
unnamed: R2.1, X2.B5 (CC2)
unnamed: LED15.C, R3.2
unnamed: C1.1, U2.30 (VCAP_1)
unnamed: R10.2, U1.6 (TNOW)
unnamed: LED18.A, R10.1
unnamed: LED17.C, R32.2
unnamed: LED15.A, X2.A4B9 (VBUS), X2.B4A9 (VBUS)
NRST: JP2.1, U2.7 (NRST); also elsewhere on the board
RTS: U1.4 (RTS)
SCL: R13.2, U2.61 (PB8), U4.4 (SCL)
SDA: R12.2, U2.62 (PB9), U4.3 (SDA)
SIG-FLOOR: U2.8 (PC0); also elsewhere on the board
SPK: U2.58 (PB6); also elsewhere on the board
SWCLK: JP2.2, U2.49 (PA14)
SWDIO: JP2.3, U2.46 (PA13)
SWO: U2.55 (PB3)
TOGGLE: U2.22 (PA6); also elsewhere on the board
UART1-RX: JP2.5, U1.8 (TX), U2.43 (PA10)
UART1-TX: JP2.4, U1.9 (RX), U2.42 (PA9)
UART2-RX: U2.17 (PA3); also elsewhere on the board
UART2-TX: U2.16 (PA2); also elsewhere on the board
UART3-RX: U2.25 (PC5); also elsewhere on the board
UART3-TX: U2.29 (PB10); also elsewhere on the board
UART4-RX: U2.15 (PA1); also elsewhere on the board
UART4-TX: U2.14 (PA0); also elsewhere on the board
UART5-RX: U2.54 (PD2); also elsewhere on the board
UART5-TX: U2.53 (PC12); also elsewhere on the board
UART6-RX: U2.38 (PC7); also elsewhere on the board
UART6-TX: U2.37 (PC6); also elsewhere on the board
VDD: C8.1, C9.+, C10.+, C12.+, C13.+, C15.+, C17.1, D1.K (C), D2.K (C), REG1.1 (VIN), REG2.1 (VIN); also elsewhere on the board
VOUT: U4.8 (VOUT)

Notes on the sheet:
STM32F446RE
REG
CH340E
USB-C
BNO055

Parts:
J1, J8: 22057045; CON_22057045_MOL
J14: 22057055; CON_22057055_MOL
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14: WS2812B_2020
Q1: C1015; SOT23
R14: 20k; R0402
R15, R16: 2k2; R0402
R17: 7.5k; R0402
U5: MAX485ESA+T; SOIC127P600X175-8N

Connections:
!RE: Q1.3 (C), R14.1, U5.2 (!RE), U5.3 (DE)
+5V: LED1.4 (VDD), LED2.4 (VDD), LED3.4 (VDD), LED4.4 (VDD), LED5.4 (VDD), LED6.4 (VDD), LED7.4 (VDD), LED8.4 (VDD), LED9.4 (VDD), LED10.4 (VDD), LED11.4 (VDD), LED12.4 (VDD), LED13.4 (VDD), LED14.4 (VDD), Q1.2 (E), R15.1, U5.8 (VCC); also elsewhere on the board
GND: J1.1, J8.1, J14.2, J14.3, LED1.2 (GND), LED2.2 (GND), LED3.2 (GND), LED4.2 (GND), LED5.2 (GND), LED6.2 (GND), LED7.2 (GND), LED8.2 (GND), LED9.2 (GND), LED10.2 (GND), LED11.2 (GND), LED12.2 (GND), LED13.2 (GND), LED14.2 (GND), R14.2, R16.2, U5.5 (GND); also elsewhere on the board
LED-L: LED1.3 (DI); also elsewhere on the board
LED-R: LED8.3 (DI); also elsewhere on the board
LED-TOP: J14.5; also elsewhere on the board
unnamed: LED1.1 (DO), LED2.3 (DI)
unnamed: LED2.1 (DO), LED3.3 (DI)
unnamed: LED3.1 (DO), LED4.3 (DI)
unnamed: LED4.1 (DO), LED5.3 (DI)
unnamed: LED5.1 (DO), LED6.3 (DI)
unnamed: LED6.1 (DO), LED7.3 (DI)
unnamed: LED8.1 (DO), LED9.3 (DI)
unnamed: LED9.1 (DO), LED10.3 (DI)
unnamed: LED10.1 (DO), LED11.3 (DI)
unnamed: LED11.1 (DO), LED12.3 (DI)
unnamed: LED12.1 (DO), LED13.3 (DI)
unnamed: LED13.1 (DO), LED14.3 (DI)
unnamed: Q1.1 (B), R17.1
unnamed: R15.2, R16.1, U5.7 (B)
SERVO-SIG: U5.6 (A); also elsewhere on the board
UART2-RX: J8.4; also elsewhere on the board
UART2-TX: J8.3; also elsewhere on the board
UART4-RX: J14.4; also elsewhere on the board
UART5-RX: U5.1 (RO); also elsewhere on the board
UART5-TX: R17.2, U5.4 (DI); also elsewhere on the board
UART6-RX: J1.4; also elsewhere on the board
UART6-TX: J1.3; also elsewhere on the board
VCC: J1.2, J8.2; also elsewhere on the board
VDD: J14.1; also elsewhere on the board

Notes on the sheet:
NEOPIXEL
ToF
CAM
RS485

Parts:
C16, C18: 0.1µ; C0603
C19: 1µ; C0603
C20: 100μ; 153CLV-0505
CN1: ML8; ML6L
D3, D4: 1N4001; SMA-DO214AC
LS1: MLT-8530; MLT-8530_JHE
R4, R30, R31: 10k; R0402
REG3: REG-5V; MYPARTS_D-PAK_TO252AA
S1: 31-XX; B3F-31XX
SV1: ML6L
SW1: SK-12D11VG3
T1: BSS138; SOT-23
X1: Seeed Studio XIAO ESP32C3; XIAO-PINHEAD

Connections:
+3V3: LS1.1, R4.1, R30.1, SW1.3 (O); also elsewhere on the board
+5V: D3.A, SV1.2; also elsewhere on the board
BOOT0: R31.1, SW1.1; also elsewhere on the board
GND: C16.2, C18.2, C19.2, C20.-, CN1.1, R31.2, REG3.4 (GND), S1.2 (S), SV1.1, SW1.4 (CASE), SW1.5 (CASE), T1.2 (S), X1.P$13 (GND); also elsewhere on the board
LED-FLOOR: CN1.6; also elsewhere on the board
LED-UI: SV1.6; also elsewhere on the board
LOADCELL-L: CN1.4; also elsewhere on the board
LOADCELL-R: CN1.3; also elsewhere on the board
MIRROR: CN1.8; also elsewhere on the board
unnamed: LS1.2, T1.1 (D)
NRST: C16.1, R30.2, S1.1; also elsewhere on the board
unnamed: D3.K (C), X1.P$14 (5V)
SERVO-SIG: CN1.7; also elsewhere on the board
SIG-FLOOR: CN1.5; also elsewhere on the board
SPK: T1.3 (G); also elsewhere on the board
TOGGLE: R4.2, SV1.5; also elsewhere on the board
UART3-RX: SV1.4; also elsewhere on the board
UART4-TX: SV1.3; also elsewhere on the board
VCC: C18.1, D4.A, REG3.3 (VOUT); also elsewhere on the board
VDD: C19.1, C20.+, CN1.2, D4.K (C), REG3.1 (VIN); also elsewhere on the board

Notes on the sheet:
XIAO
SPK
RESET
BOOT0

Board: 2 copper layers, 106.0 x 53.0 mm, 72 parts (0 on the bottom side), 63 nets.

Other parts of the board:
U3: SUNA_LIB_M5STAMP_C3U_MATE; SUNA_LIB_M5STAMPC3UMATE

Their connections:
+5V: U3.5V1P, U3.5V2P; also elsewhere on the board
GND: U3.GND2P, U3.GND3P, U3.GND4P; also elsewhere on the board
UART3-TX: U3.G20P; also elsewhere on the board

File PCB/01-main/01-main_top_bom.csv:

Comment,Designator,Footprint,LCSC Part #
0.1µ,C2 C3 C4 C5 C6 C7 C11 C14 C16 C18,C0603,C14663
1N4001,D1 D2 D4,SMA-DO214AC,C727079
1µ,C8 C17 C19,C0603,C15849
2k2,R15 R16,R0402,C25879
4.7µ,C1,C0603,C19666
5k1,R1 R2,R0402,C25879
7.5k,R17,R0402,C25918
10k,R4 R12 R13 R30 R31,R0402,C25744
20k,R14,R0402,C25765
100μ,C9 C13 C20,153CLV-0505,C72487
270,R3 R10 R32,R0402,C25099
BLUE,LED15,SML0603,C118339
BSS138,T1,SOT-23,C112239
C1015,Q1,SOT23,C181170
CH340ESMD,U1,MSOP10,C99652
MAX485ESA+T,U5,SOIC127P600X175-8N,MAX485ED
MLT-8530,LS1,MLT-8530_JHE,C94599
STM32F446RET6,U2,LQFP64-10X10MM,C69336
WHITE,LED17 LED18,SML0603,C389521
WS2812B_2020,LED1 LED2 LED3 LED4 LED5 LED6 LED7 LED8 LED9 LED10 LED11 LED12 LED13 LED14,WS2812B_2020,C965555
usb-c,X2,USB_C_CUSB31-CFM2AX-01-X,C2987386

## EAGLE design PCB/04-bottom/04-bottom.brd

Parts:
AMP1, AMP2: NJU77551F; SOT23-5
CN1: ML8-R; ML6
GND1, GND2: PAD_GND; GND
J1, J2, J3, J4, J7: 5267-3
J5, J6: 22057045; CON_22057045_MOL
JP1, JP3: PINHD-1X4; 1X04
JP2, JP4: PINHD-1X2; 1X02
R1, R2, R5, R6: 1k; R0805
R3, R4, R7, R8: 330k; R0805
R9, R10: 10k; R0402
U1: MOUDLE-SEEEDUINO-XIAO; MOUDLE14P-2.54-21X17.8MM
VDD1: PAD_VDD; VDD
VDD_IN: PAD_VDD; VDD
XT1: XT-30_L

Connections:
+3V3: AMP1.5 (V+), AMP2.5 (V+), J5.1, J6.1, JP1.1, JP3.1, R9.2, R10.2, U1.12 (3V3)
BATT+: VDD_IN.P$1, XT1.1
GND: AMP1.2 (V-), AMP2.2 (V-), CN1.1, GND1.P$1, GND2.P$1, J1.P$3 (-3), J2.P$3 (-3), J3.P$3 (-3), J4.P$3 (-3), J5.2, J6.2, J7.P$3 (-3), JP1.2, JP3.2, R3.2, R7.2, U1.13 (GND), XT1.2
LED-FLOOR: CN1.6
LOADCELL-L: AMP1.4 (OUT), CN1.4, R4.2
LOADCELL-R: AMP2.4 (OUT), CN1.3, R8.2
MIRROR: CN1.8, U1.7 (PB08_A6_D6_TX)
unnamed: J5.3, R2.1
unnamed: J5.4, R1.1
unnamed: AMP1.3 (-IN), R2.2, R4.1
unnamed: AMP1.1 (+IN), R1.2, R3.1
unnamed: J6.3, R6.1
unnamed: J6.4, R5.1
unnamed: AMP2.3 (-IN), R6.2, R8.1
unnamed: AMP2.1 (+IN), R5.2, R7.1
SCL: JP1.3, JP3.3, R10.1, U1.6 (PA9_A5_D5_SCL)
SDA: JP1.4, JP3.4, R9.1, U1.5 (PA8_A4_D4_SDA)
SERVO-SIG: CN1.7, J1.P$1 (-1), J2.P$1 (-1), J3.P$1 (-1), J4.P$1 (-1), J7.P$1 (-1)
SIG-FLOOR: CN1.5
VDD: CN1.2, J1.P$2 (-2), J2.P$2 (-2), J3.P$2 (-2), J4.P$2 (-2), J7.P$2 (-2), U1.14 (5V), VDD1.P$1
XSHUT1: JP2.1, U1.11 (PA6_A10_D10_MOSI)
XSHUT2: JP4.1, U1.1 (PA02_A0_D0)

Notes on the sheet:
XIAO
SERVO
CONN
VL53L0X
OP-AMP
にゅーぷるあっぷ♪
PULL PULL PULL-UP♪ PULL PULL PULL PULL PULL PULL PULL PULL PULL PULL PULL-UP PULL-UP♪
くれらっぷの歌

Board: 2 copper layers, 128.0 x 129.5 mm, 30 parts (0 on the bottom side), 20 nets.

## EAGLE design PCB/02-UI/02-ui.brd

Parts:
JP1: PINHD-1X2; 1X02
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14: WS2812B_2020
Q2: BSS84; SOT23
TFT1: 2.8TFT
TP1: TPTP10SQ; TP10SQ
TP2, TP3, TP4, TP5, TP6: TPTP10R; TP10R
X1: SEEEDUINO-XIAO-DIP; XIAO-PINHEAD

Connections:
+3V3: Q2.2 (S), TFT1.VCC, X1.P$12 (3V3)
+5V: LED1.4 (VDD), LED2.4 (VDD), LED3.4 (VDD), LED4.4 (VDD), LED5.4 (VDD), LED6.4 (VDD), LED7.4 (VDD), LED8.4 (VDD), LED9.4 (VDD), LED10.4 (VDD), LED11.4 (VDD), LED12.4 (VDD), LED13.4 (VDD), LED14.4 (VDD), TP2.TP, X1.P$14 (5V)
BACKLIGHT: Q2.1 (G), X1.P$4 (PA11_A3_D3)
BIN: JP1.2, TP5.TP
GND: JP1.1, LED1.2 (GND), LED2.2 (GND), LED3.2 (GND), LED4.2 (GND), LED5.2 (GND), LED6.2 (GND), LED7.2 (GND), LED8.2 (GND), LED9.2 (GND), LED10.2 (GND), LED11.2 (GND), LED12.2 (GND), LED13.2 (GND), LED14.2 (GND), TFT1.GND, TP1.TP, X1.P$13 (GND)
LED: LED1.3 (DI), TP6.TP
MISO: TFT1.T_DO, X1.P$10 (PA5_A9_D9_MISO)
MOSI: TFT1.MOSI, TFT1.T_DIN, X1.P$11 (PA6_A10_D10_MOSI)
unnamed: LED1.1 (DO), LED2.3 (DI)
unnamed: LED2.1 (DO), LED3.3 (DI)
unnamed: LED3.1 (DO), LED4.3 (DI)
unnamed: LED4.1 (DO), LED5.3 (DI)
unnamed: LED6.1 (DO), LED7.3 (DI)
unnamed: LED10.1 (DO), LED11.3 (DI)
unnamed: LED8.1 (DO), LED9.3 (DI)
unnamed: LED9.1 (DO), LED10.3 (DI)
unnamed: LED5.1 (DO), LED6.3 (DI)
unnamed: LED11.1 (DO), LED12.3 (DI)
unnamed: LED12.1 (DO), LED13.3 (DI)
unnamed: LED13.1 (DO), LED14.3 (DI)
unnamed: LED7.1 (DO), LED8.3 (DI)
RX: TP3.TP, X1.P$8 (PB09_A7_D7_RX)
SCK: TFT1.SCK, TFT1.T_CLK, X1.P$9 (PA7_A8_D8_SCK)
TFT_CS: TFT1.CS, X1.P$1 (PA02_A0_D0)
TFT_DC: TFT1.DC, X1.P$3 (PA10_A2_D2)
TFT_LED: Q2.3 (D), TFT1.LED
TFT_RST: TFT1.RST, X1.P$2 (PA4_A1_D1)
TOUCH_CS: TFT1.T_CS, X1.P$6 (PA9_A5_D5_SCL)
TOUCH_IRQ: TFT1.T_IRQ, X1.P$5 (PA8_A4_D4_SDA)
TX: TP4.TP, X1.P$7 (PB08_A6_D6_TX)

Notes on the sheet:
NEOPIXEL
XIAO RP2040
CONN
TOGGLE

Board: 2 copper layers, 105.0 x 60.0 mm, 24 parts (7 on the bottom side), 30 nets.

File PCB/02-UI/Data/02-ui_top_bom.csv:

Comment,Designator,Footprint,LCSC Part #
WS2812B_2020,LED1 LED2 LED3 LED4 LED5 LED6 LED7 LED8 LED9 LED10 LED11 LED12 LED13 LED14,WS2812B_2020,C965555

## EAGLE design PCB/05-PWR/05-PWR.brd

Parts:
F1: SHK20L
TP1, TP2: TPSQPAD1-20; P1-20
TP3: PTR1TP15R; TP15R
TP4: PTR1TP15SQ; TP15SQ
U$1, U$2, U$3, U$4: PAD_VDD; VDD

Connections:
GND: TP4.TP, U$1.P$1, U$2.P$1
unnamed: F1.1A, U$3.P$1
unnamed: F1.2A, TP2.TP
VDD: TP1.TP, TP3.TP, U$4.P$1

Notes on the sheet:
Connector
Voltmeter
回路図のスペースが余ってしまった。
うーたん解雇反対!!
おれたちのうーたんを返せ!!

Board: 2 copper layers, 66.0 x 22.0 mm, 9 parts (2 on the bottom side), 4 nets.

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2022 Ultra Librarian. All rights reserved.
